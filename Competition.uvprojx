# Keil uVision project Competition.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Competition
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Delay.h Delay.S fonction.c fonction.h LCDTests.h main.c PLL.c PLL.h random.h random.s SSD2119.c SSD2119.h tm4c123gh6pm.h
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5, CMSIS:RTOS:Keil RTX 4.78.0, Device:Startup 1.0.0
